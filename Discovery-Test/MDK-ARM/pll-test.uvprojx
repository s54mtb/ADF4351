# Keil uVision project pll-test.uvprojx, settings and files
target S54MTB-PLL (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: s54mtbPLL
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;..\..\..\trunk
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group HAL
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_pwr.c stm32f0xx_hal_cortex.c stm32f0xx_hal.c stm32f0xx_hal_spi.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi_ex.c
  group System
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072xb.s
  group App
    ../Src/: stm32f0xx_it.c stm32f0xx_hal_msp.c main.c spi.c gpio.c
    ../../: adf4351.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
